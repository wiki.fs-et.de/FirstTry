# EAGLE board ScootyPuffControl_1.2 (EAGLE 5.06), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
+5V  (via drill 0.41 pad 0.81, 0.61 pad 0.81)
  Top 0.254: R110.2 71.02,35.24 v69.85,35.24
  Top 0.305: 106.68,28.57 R306.2 103.5,28.57 102.23,29.84 102.23,34.29 100.97,35.56 v97.16,35.56 87.63,35.56 86.73,36.46 IC102.19 | R111.2 R112.2 R113.2 R108.2 R109.2 R110.2 | v85.09,27.3 81.92,27.3 81.28,26.67 81.28,26.04 79.75,24.5 IC305.8 79.75,22.86 79.09,22.86 IC305.7
  Top 0.406: IC303.1 64.13,37.47 63.18,38.42 61.91,38.42 61.28,37.78 60.37,37.78 C306.2 v60.01,36.2 | v58.1,54.29 R304.2
  Top 0.61: C306.2 59.64,37.78 | J100.P$36 99.06,92.71 v97.79,92.71 96.52,92.71 J100.P$34 | v101.6,81.28 99.69,79.38 99.69,55.24 v97.16,52.7 | J103.P$6 100.33,15.24 99.06,16.51 99.06,26.67 98.42,27.3 v97.16,27.3 88.27,27.3 IC301.4 | J102.P$6 54.61,15.24 55.24,15.88 60.96,15.88 61.59,16.51 v61.59,31.11 v69.85,31.11 81.92,31.11 83.19,29.84 83.14,29.84 C305.+
  Top 1.016: IC301.2 88.27,27.3 88.27,28.57 | 88.27,28.57 IC301.4 | C305.+ 85.13,29.8 86.36,28.57 88.27,28.57
  Bottom 0.254: v69.85,31.11 v69.85,35.24
  Bottom 0.406: v58.1,54.29 58.1,42.86 60.01,40.96 v60.01,36.2 | v90.81,29.21 92.08,29.21 92.08,29.84
  Bottom 0.61: v97.79,92.71 100.33,92.71 101.6,91.44 v101.6,81.28 | v97.16,52.7 v97.16,35.56 v97.16,27.3 | v60.01,36.2 60.01,32.7 v61.59,31.11
  Bottom 1.016: 80.64,25.4 80.64,37.47 91.44,37.47 91.44,29.84 92.08,29.84 99.69,29.84 99.69,25.4 80.64,25.4
  other vias: 85.09,29.21 87,27.3 88.9,27.3 90.81,27.3 87,29.21 88.9,29.21
  pour Top (isolate 0.61, no thermals): 99.69,21.91 81.28,21.91 81.28,32.07 99.69,32.07
  pour Bottom: 80.64,26.04 80.64,36.83 90.81,36.83 90.81,29.84 91.44,29.21 99.06,29.21 99.06,26.04
+12V  (via drill 0.41 pad 0.81, 0.61 pad 0.81)
  Top 0.305: v106.05,26.04 R305.2
  Top 0.61: IC201.5 37.15,19.68 37.47,19.37 37.47,13.97 C201.2 D201.A 35.1,12.24 | IC221.5 36.83,76.83 37.47,76.2 37.47,71.53 C221.2 D221.A 34.92,70.94 33.66,69.85 v26.67,69.85 | v26.67,41.27 33.66,41.27 35.1,42.73 D211.A C211.2 37.47,42.77 37.47,47.62 36.83,48.26 IC211.5 | v26.67,14.61 29.21,12.06 34.92,12.06 35.1,12.24 | D6.A 113.48,95.3 C251.2 | IC231.5 123.19,36.83 122.56,37.47 122.56,41.68 C241.2 D231.A 124.92,43.63 125.41,44.13 v133.67,44.13 | 124.78,71.12 C231.2 122.56,70.89 122.56,66.04 123.19,65.41 IC241.5 | 124.78,71.12 D5.A | IC251.5 123.19,93.98 122.56,94.61 v122.56,97.79 | v133.67,72.71 125.09,72.71 124.78,72.39 124.78,71.12 | 35.1,12.24 35.1,12.06 43.18,12.06 43.18,12.7 C261.+ 43.2,14.63 43.81,15.24 50.8,15.24 52.07,13.97 v52.07,12.06 | 123.8,12.06 C262.+ 125.12,12.06 | v62.87,13.34 62.87,20 63.5,20.64 73.66,20.64 74.3,20 74.3,13.97 74.93,13.34 J303.6 77.47,15.24 78.11,15.88 81.92,15.88 82.55,15.24 J303.2
  Top 1.016: D6.A v111.76,97.79 93.98,97.79 | J100.P$30 91.44,97.79 93.98,97.79 | 93.98,97.79 J100.P$32 | v107.95,12.06 123.8,12.06 | v133.67,13.34 132.4,12.06 125.12,12.06 | v97.16,13.34 97.16,19.68 96.52,20.32 | 96.52,20.32 87,20.32 85.72,19.05 85.72,13.97 85.09,13.34 J303.2 | R303.2 96.37,22.07 96.52,21.59 96.52,20.32
  Bottom 0.305: 106.05,13.34 v106.05,26.04
  Bottom 0.61: v26.67,69.85 v26.67,41.27 v26.67,14.61 | 122.56,98.74 v122.56,97.79 | v62.87,13.34 53.34,13.34 v52.07,12.06
  Bottom 1.016: v133.67,13.34 v133.67,44.13 v133.67,72.71 133.67,97.47 132.4,98.74 122.56,98.74 112.71,98.74 v111.76,97.79 | v107.95,12.06 106.68,13.34 106.05,13.34 v97.16,13.34
AD0
  Top 0.254: IC101.98 67.94,64.68 67.94,73.03 | IC108.1 70.17,83.39 70.17,82.87 69.85,82.55 69.22,82.55 68.88,82.22 IC108.4 68.88,79.95 C117.1 69.93,79.61 70.17,79.38 70.17,77.15 67.94,74.93 67.94,73.03 | 67.94,73.03 67.94,73.34
AD1
  Top 0.254: IC101.99 67.31,64.61 67.31,76.52 67.63,76.83 67.63,79.38 67.39,79.61 C116.1 66.58,79.71 66.34,79.71 IC107.4 66.34,82.22 66.67,82.55 67.31,82.55 67.63,82.87 67.63,83.39 IC107.1
AD2
  Top 0.254: IC101.100 66.67,64.54 66.67,75.88 65.09,77.47 65.09,79.38 64.85,79.61 C115.1 63.8,79.95 IC106.4 63.8,82.22 64.14,82.55 64.77,82.55 65.09,82.87 65.09,83.39 IC106.1
AD3
  Top 0.254: IC101.1 69.62,57.78 67.94,57.78 66.04,59.69 66.04,75.56 64.77,76.83 63.5,76.83 62.55,77.79 62.55,79.38 62.31,79.61 C114.1 61.26,79.95 IC105.4 61.26,82.22 61.59,82.55 62.23,82.55 62.55,82.87 62.55,83.39 IC105.1
AD4
  Top 0.254: IC101.2 69.69,57.15 67.63,57.15 65.41,59.37 65.41,75.25 64.45,76.2 60.96,76.2 60.01,77.15 60.01,79.38 59.77,79.61 C113.1 59.05,79.69 58.72,80.03 IC104.4 58.72,82.22 59.05,82.55 59.69,82.55 60.01,82.87 60.01,83.39 IC104.1
AD5
  Top 0.203: 56.18,81.58 56.5,81.58 56.83,81.92 56.83,82.07 57.47,82.71 57.47,83.39
  Top 0.254: IC101.5 70.54,55.88 67.94,55.88 64.77,59.05 64.77,74.93 64.14,75.56 58.42,75.56 57.47,76.52 57.47,79.38 57.23,79.61 C112.1 56.52,79.69 56.18,80.03 56.18,81.58 IC103.4 | 57.47,83.39 IC103.1
AVCC  (via drill 0.41 pad 0.81)
  Top 0.254: IC304.5 58.42,56.52 59.6,55.33 C309.+ | IC101.4 73.01,59.05 v72.71,58.74 73.03,59.05 v73.03,60.96 73.03,62.43 IC101.94
  Top 0.406: v64.45,55.24 62.63,55.24 C309.+
  Bottom 0.254: v73.03,60.96 73.03,61.1
  Bottom 0.406: v72.71,58.74 73.34,58.1 73.34,57.32 C109.2 71.26,55.24 v64.45,55.24 | 73.03,61.1 C110.2
GND  (via drill 0.41 pad 0.81, 0.61 pad 0.81)
  Top 0.254: v83.82,63.5 IC101.63 | IC101.23 79.38,51.98 v79.38,53.34 | IC101.84 77.47,65.06 v77.47,64.77 74.45,61.75 | IC101.53 87.72,60.33 v87.63,59.69 | IC101.73 80.64,67.4 v80.64,66.67 | IC101.13 76.2,55.88 v76.83,55.88 | IC101.43 86.08,57.15 v85.72,57.15 | IC101.33 82.82,53.34 v81.92,53.34 | v73.98,59.69 73.98,61.28 74.45,61.75 | IC101.3 71.75,58.51 v71.75,59.69 | 62.46,58.42 C309.- | v56.83,85.09 IC103.2 56.83,82.87 56.52,82.55 55.88,82.55 55.56,82.23 55.56,77.79 | v59.37,85.09 IC104.2 | v61.91,85.09 IC105.2 | v64.45,85.09 IC106.2 | v66.99,85.09 IC107.2 | v69.53,85.09 IC108.2 | 55.56,77.79 55.56,77.47 54.29,76.2 IC222.2 | C113.2 58.34,77.86 58.1,78.11 58.1,80.01 v57.78,80.33 | C114.2 60.88,77.86 60.64,78.11 60.64,80.01 v60.33,80.33 | C115.2 63.42,77.86 63.18,78.11 63.18,80.01 v62.87,80.33 | C116.2 65.96,77.86 65.72,78.11 65.72,80.01 v65.41,80.33 | C117.2 68.5,77.86 68.26,78.11 68.26,80.01 v67.94,80.33 | C112.2 55.64,77.86 55.56,77.79 | C204.1 v65.41,46.04 | C214.1 v65.41,48.58 | C1.1 v65.41,51.12 | IC203.2 57.78,46.35 v56.83,47.31 | IC2.2 57.78,51.44 v56.83,52.39 | IC213.2 57.78,48.9 v56.83,49.85 | v53.34,48.58 C213.1 | IC233.2 101.6,62.23 100.97,61.59 100.97,58.74 101.52,58.18 C233.1 103.43,58.18 | 103.43,58.18 C243.1 106.05,58.18 | 106.05,58.18 C253.1 | 106.05,58.18 106.05,62.02 106.68,62.65 IC253.2 | IC243.2 104.14,62.65 103.5,62.02 103.5,58.26 103.43,58.18 | IC101.93 74.41,61.75 74.45,61.75
  Top 0.305: 42.55,46.99 42.55,48.58 41.59,49.53 v34.61,49.53 | IC211.3 42.55,46.99 | IC212.2 46.04,47.62 45.72,47.31 45.72,46.04 45.4,45.72 43.18,45.72 42.55,46.35 42.55,46.99 | IC222.2 46.04,76.2 45.72,75.88 45.72,74.61 45.4,74.3 43.18,74.3 42.55,74.93 42.55,75.56 | IC221.3 42.55,75.56 | v34.61,20.95 41.59,20.95 42.55,20 42.55,18.41 | IC202.2 46.35,19.05 45.72,18.41 45.72,17.78 45.09,17.14 43.18,17.14 42.55,17.78 42.55,18.41 | C308.1 55.93,58.47 56.52,59.05 58.42,59.05 59.05,58.42 IC304.3 | IC232.2 113.98,37.47 114.3,37.78 114.3,38.73 114.62,39.05 117.16,39.05 117.47,38.73 117.47,38.1 | 117.47,38.1 117.47,36.51 118.43,35.56 v125.73,35.56 | IC231.3 117.47,38.1 | IC242.2 113.98,66.04 114.3,66.36 114.3,67.31 114.62,67.63 117.16,67.63 117.47,67.31 117.47,66.67 | 117.47,66.67 117.47,65.09 118.43,64.14 v125.73,64.14 | 117.47,66.67 IC241.3 | 42.55,18.41 IC201.3 | v116.84,82.55 LED104.C | 48.9,97.79 C111.1 | LED303.C LED302.C LED301.C 105.63,13.55 J103.P$2 | 42.55,75.56 42.55,77.15 41.59,78.11 v34.61,78.11 | IC102.11 81.53,39.62 80.96,39.05 v80.64,39.05 | C203.1 v53.34,46.04 | v53.34,51.12 C223.1 | C253.1 v107.31,56.52 | C234.1 C244.1 C254.1 106.68,73.03 v106.05,73.66 | v99.69,52.7 102.23,55.24 C233.1 | IC305.1 79.75,25.77 79.06,25.08 v75.56,25.08
  Top 0.406: IC304.2 61.28,57.47 61.28,58.42 | IC304.3 61.28,58.42 | 127,80.64 127,80.01 v126.36,79.38 | v110.49,90.17 IC252.2 | 66.99,38.42 C307.- 66.44,39.37 IC303.3 65.12,39.66 64.45,40.32 61.91,40.32 61.28,39.69 60.28,39.69 C306.1 59.74,39.69 | 61.28,58.42 62.46,58.42 | C309.- v62.55,59.69 | v51.44,73.03 J101.2 | v51.44,62.87 J101.10 54.93,62.87 C308.1 | v68.58,38.42 66.99,38.42 | 66.99,38.42 IC303.2 | v33.66,34.29 33.66,33.66 38.73,33.66 40.64,31.75 LED101.C | LED102.C 40.64,60.33 38.73,62.23 34.29,62.23 v33.66,62.87 | v33.66,91.44 34.29,90.81 38.73,90.81 40.64,88.9 LED103.C | v126.36,22.23 125.73,22.86 121.28,22.86 119.38,24.77 LED106.C | LED105.C 119.38,53.34 121.28,51.44 125.73,51.44 v126.36,50.8 | C251.1 116.44,94.84 v115.57,93.98
  Top 0.61: v33.66,38.1 33.66,38.73 34.29,39.37 37.47,39.37 38.73,40.64 38.73,42.55 | IC221.3 39.37,75.56 38.73,74.93 38.73,71.12 | IC211.3 39.37,46.99 38.73,46.35 38.73,42.55 | 38.73,71.12 38.73,69.22 37.47,67.94 34.92,67.94 v33.66,66.67 | 38.73,71.12 C221.1 | 38.73,42.55 C211.1 | C201.1 40.01,13.97 38.73,15.24 38.73,17.78 39.37,18.41 IC201.3 | C251.1 IC251.3 | 55.88,97.79 58.42,97.79 | 58.42,97.79 60.96,97.79 | 60.96,97.79 63.5,97.79 | 63.5,97.79 66.04,97.79 | 66.04,97.79 68.58,97.79 | 58.42,97.79 J100.P$4 | 60.96,97.79 J100.P$6 | 63.5,97.79 J100.P$8 | 66.04,97.79 J100.P$10 | 68.58,97.79 J100.P$12 | 68.58,97.79 86.36,97.79 | 86.36,97.79 J100.P$26 | J100.P$28 88.9,97.79 86.36,97.79 | 55.88,97.79 J100.P$2 | 55.88,97.79 48.9,97.79 38.1,97.79 35.56,95.25 v33.66,95.25 | IC241.3 120.65,66.67 121.28,67.31 121.28,71.12 | 121.28,71.12 121.28,72.39 123.83,74.93 125.73,74.93 v126.36,75.56 | 121.28,71.12 C231.1 | IC231.3 120.65,38.1 121.28,38.73 121.28,42.55 | 121.28,42.55 121.28,43.81 124.46,46.99 v126.36,46.99 | 121.28,42.55 C241.1 | v46.99,12.7 C261.- | v59.69,11.75 J102.P$2 | v105.41,11.75 J103.P$2 | v80.01,14.61 J303.4
  Top 1.016: C305.- 83.22,24.84 IC301.1 85.95,22.95 v85.94,22.86 | C304.- v93.34,31.75
  Bottom 0.254: 79.38,49.9 C105.1 | 76.69,55.88 v76.83,55.88 79.38,55.88 79.38,53.98 | C106.1 83.19,53.2 | v85.72,57.15 85.72,57.01 | 89.81,59.05 C103.1 | 80.64,68.85 C101.1 | v80.64,66.67 79.69,65.09 81.92,63.5 v83.82,63.5 83.82,61.59 86.04,59.37 | v77.47,64.77 78.74,64.77 | v87.63,59.69 86.36,59.69 86.04,59.37 | 86.04,59.37 85.27,58.6 85.27,57.6 v85.72,57.15 | 81.28,53.98 v81.92,53.34 | 79.38,53.98 81.28,53.98 | v79.38,53.34 79.38,53.98 | v85.72,57.15 83.82,57.15 81.28,54.61 81.28,53.98 | 71.61,59.69 v71.75,59.69 v73.98,59.69 | v56.83,85.09 v59.37,85.09 v61.91,85.09 v64.45,85.09 v66.99,85.09 v69.53,85.09 69.53,80.96 68.9,80.33 v67.94,80.33 v65.41,80.33 v62.87,80.33 v60.33,80.33 v57.78,80.33 | v53.34,48.58 55.56,48.58 v56.83,49.85
  Bottom 0.305: 32.7,92.08 v31.75,93.34 | 127.32,18.41 v126.36,18.41 | 127.32,46.99 v126.36,46.99 | 127.32,79.38 v126.36,79.38 | v53.34,46.04 v53.34,48.58 v53.34,51.12 | 107.31,57.15 107.31,59.45 | v106.05,73.66 107.95,71.75 107.95,67.94 107.31,67.31 107.31,57.15 | v107.31,56.52 107.31,57.15
  Bottom 0.406: 32.7,20.95 v34.61,20.95 | 127.32,91.44 127.06,94.05 | 127.06,94.05 127,94.61 | v110.49,90.17 110.49,88.58 111.12,87.95 111.12,83.82 112.39,82.55 v116.84,82.55 118.75,82.55 121.28,80.01 125.73,80.01 v126.36,79.38 | v79.38,53.34 79.38,49.9 | 76.69,55.88 C108.1 | 85.72,57.01 C102.1 | 89.81,59.05 88.27,59.05 v87.63,59.69 | C106.1 83.04,53.34 v81.92,53.34 | v80.64,66.67 80.64,68.85 | C107.1 76.69,64.77 v77.47,64.77 | C104.1 84.6,63.5 v83.82,63.5 | C109.1 71.61,58.42 71.61,59.69 C110.1 69.22,59.69 v62.55,59.69 | v51.44,73.03 52.39,73.03 53.02,72.39 53.02,63.5 52.39,62.87 | C105.1 79.06,50.12 | v115.57,93.98 117.16,93.98 118.11,94.93 126.17,94.93 127.06,94.05 | 68.58,21.27 v68.58,38.42 | 79.38,5.71 78.74,6.35
  Bottom 0.61: v33.66,34.29 33.66,31.43 32.7,31.11 | 39.37,5.71 43.18,5.71 43.81,6.35 | 32.7,66.67 v33.66,66.67 | 85.09,5.71 J302.P$4 | 63.5,5.71 64.14,6.35 | 105.41,5.71 v105.41,11.75 | 68.58,21.27 55.24,21.27 50.48,16.51 50.48,5.71 | 32.7,88.27 32.72,88.28 | 46.99,5.71 v46.99,12.7 | 123.19,12.7 123.19,8.89 123.35,8.73 | 80.01,5.71 v80.01,14.61
  Bottom 1.016: 59.69,5.71 v59.69,11.75 | 44.45,5.71 43.81,5.08 | v85.94,22.86 87.95,18.73 J302.P$6
  Bottom 10.16: 32.7,92.08 32.7,88.27 32.7,66.67 32.7,31.11 32.7,20.95 32.7,13.02 39.37,5.71 44.45,5.71 46.99,5.71 50.48,5.71 59.69,5.71 63.5,5.71 79.38,5.71 80.01,5.71 85.09,5.71 105.41,5.71 120.33,5.71 123.35,8.73 127.32,12.7 127.32,18.41 127.32,46.99 127.32,79.38 127.32,91.44
  other vias: 33.66,93.34 31.75,95.25 31.75,36.2 33.66,36.2 31.75,38.1 31.75,62.87 31.75,64.77 33.66,64.77 31.75,91.44 31.75,66.67 31.75,34.29 128.27,46.99 126.36,48.9 128.27,48.9 128.27,50.8 128.27,75.56 126.36,77.47 128.27,77.47 128.27,79.38 128.27,18.41 126.36,20.32 128.27,20.32 128.27,22.23
  pour Top (isolate 0.305, no thermals): 25.4,96.52 36.83,96.52 36.83,90.17 25.4,90.17
  pour Top (isolate 0.305, no thermals): 25.4,39.37 36.83,39.37 36.83,33.02 25.4,33.02
  pour Top (isolate 0.305, no thermals): 25.4,67.94 36.83,67.94 36.83,61.59 25.4,61.59
  pour Bottom (no thermals): 87,19.68 87,12.7 85.09,10.79 85.09,1.27 97.79,1.27 97.79,10.16 95.89,12.7 95.89,19.68
  pour Top (isolate 0.305, no thermals): 134.62,17.14 123.19,17.14 123.19,23.5 134.62,23.5
  pour Top (isolate 0.305, no thermals): 134.62,45.72 123.19,45.72 123.19,52.07 134.62,52.07
  pour Top (isolate 0.305, no thermals): 134.62,74.3 123.19,74.3 123.19,80.64 134.62,80.64
  pour Bottom (isolate 0.61): 27.94,16.51 27.94,99.06 132.08,99.06 132.08,20.95 121.92,10.79 109.86,10.79 59.05,9.53 49.53,10.16 34.29,10.16
  pour Top (no thermals): 87.63,19.05 87.63,11.43 95.25,11.43 95.25,19.05
IU1
  Top 0.254: IC101.8 66.67,49.89 66.67,47.62 66.04,46.99 62.23,46.99 61.91,46.67 61.91,46.62 C204.2 | C204.2 61.91,46.31 | IC203.1 58.6,47.01 IC203.4 61.66,45.7 C204.2
IU2  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.95 69.85,64.9 69.85,71.75 v70.48,72.39 | IC233.1 100.95,63.69 IC233.4 102.25,66.03 v102.23,66.04
  Top 0.305: v101.6,68.58 C234.2
  Bottom 0.305: v70.48,72.39 100.97,72.39 102.23,71.12 102.23,68.58 | 102.23,68.58 v102.23,66.04 | 102.23,68.58 v101.6,68.58
IV1
  Top 0.254: IC101.7 65.61,49.53 62.23,49.53 61.87,49.16 C214.2 61.91,48.85 61.91,48.26 61.9,48.24 IC213.4 59.91,48.36 58.72,49.55 IC213.1
IV2  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.96 69.22,64.83 69.22,72.39 v70.48,73.66 | IC243.1 103.49,63.69 IC243.4 104.79,66.03 v104.78,66.04
  Top 0.305: v104.14,68.58 C244.2
  Bottom 0.305: 104.78,68.58 104.78,71.12 102.23,73.66 v70.48,73.66 | 104.78,68.58 v104.78,66.04 | 104.78,68.58 v104.14,68.58
IW1
  Top 0.254: IC101.6 67.44,52.07 62.23,52.07 61.87,51.7 C1.2 | C1.2 61.87,51.16 | C1.2 61.91,51.39 61.91,50.8 61.9,50.78 IC2.4 58.6,52.09 IC2.1
IW2  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.97 68.58,64.76 68.58,73.03 v70.48,74.93 | IC253.1 106.03,63.69 IC253.4
  Top 0.305: IC253.4 107.31,65 107.31,66.04 106.68,66.67 v106.68,68.58 C254.2
  Bottom 0.254: 103.5,74.93 106.05,72.39
  Bottom 0.305: v70.48,74.93 103.5,74.93 | 106.05,72.39 106.68,71.75 v106.68,68.58
LED1
  Top 0.254: IC101.72 83.19,69.23 83.19,69.85 81.92,71.12 81.28,71.12 80.33,72.07 R101.2
LED2
  Top 0.254: IC101.71 83.82,69.16 83.82,70.17 82.55,71.44 R102.2
LED3
  Top 0.254: IC101.70 84.2,68.83 | 84.2,68.83 84.45,69.08 | R103.2 84.77,69.4 84.2,68.83
LED4
  Top 0.254: R104.2 87,70.92 IC101.69
LED5
  Top 0.254: R105.2 89.22,71.44 88.9,71.12 87.9,71.12 IC101.68
LED6
  Top 0.254: R106.2 91.44,71.12 90.81,70.48 87.98,70.48 IC101.67
N$1
  Top 0.254: IC101.32 86.08,49.38 IC102.3
N$2
  Top 0.305: LED301.A 109.86,25.61 R305.1
N$3
  Top 0.305: LED302.A 112.39,17.78 111.12,19.05 111.12,27.94 110.49,28.57 R306.1
N$4
  Top 0.61: IC201.7 31.11,17.14 30.48,16.51 30.48,15.66 R201.1
N$5  (via drill 0.41 pad 0.81)
  Top 0.61: v38.73,19.68 IC201.4 | v38.73,31.75 R202.1
  Bottom 0.61: v38.73,19.68 v38.73,31.75
N$6  (via drill 0.41 pad 0.81)
  Top 0.61: v38.73,48.26 IC211.4 | v38.73,60.33 R212.1
  Bottom 0.61: v38.73,48.26 v38.73,60.33
N$7
  Top 0.61: R211.1 30.38,44.98 31.11,45.72 IC211.7
N$8
  Top 0.305: LED303.A 114.94,16.19 111.76,19.37 111.76,30.48 111.12,31.11 R307.1
N$9  (via drill 0.41 pad 0.81)
  Top 0.61: v38.73,76.83 IC221.4 | v38.73,88.9 R222.1
  Bottom 0.61: v38.73,76.83 v38.73,88.9
N$10
  Top 0.61: IC221.7 31.11,74.3 30.48,73.66 30.48,72.49 R221.1
N$11
  Top 0.61: IC211.8 32.62,44.45 C212.2 32.2,44.04 D211.C
N$12
  Top 0.61: IC201.8 32.62,15.88 C202.2 32.38,13.97 D201.C
N$14
  Top 0.61: 33.02,73.03 31.98,73.03 C222.2 | 33.02,73.03 IC221.8 | D221.C 32.2,72.84 33.02,73.03
N$21
  Top 0.254: IC107.3 66.34,84.47 66.04,84.77 J100.P$9
N$23
  Top 0.254: IC101.27 82.83,49.09 IC102.8
N$24  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.10 76.2,58 v76.2,58.74 | J101.9 v61.59,64.14
  Bottom 0.254: v61.59,64.14 60.64,64.14 60.33,64.45 60.33,70.17 60.64,70.48 66.99,70.48 76.2,61.28 v76.2,58.74
N$26
  Top 0.254: IC101.31 85.43,49.32 IC102.4
N$27
  Top 0.254: IC101.28 83.48,49.15 IC102.7
N$28
  Top 0.254: IC101.30 84.78,49.26 IC102.5
N$29
  Top 0.254: IC101.29 84.13,49.21 IC102.6
N$30
  Top 0.305: IC305.6 78.44,22.2 79.06,21.59 81.92,21.59 82.55,20.95 J303.1
N$31  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.11 77.47,58.56 v77.47,58.42 | v61.59,74.3 J101.1
  Bottom 0.254: v61.59,74.3 64.14,74.3 77.47,60.96 v77.47,58.42
N$32  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.9 74.93,57.44 v74.93,58.42 | v61.59,69.22 J101.5
  Bottom 0.254: v61.59,69.22 67.31,69.22 74.93,61.59 v74.93,58.42
N$33
  Top 1.016: IC301.3 93.31,24.84 C304.+ 96.41,24.8 R303.1
N$34
  Top 0.305: IC304.1 59.37,56.52 58.74,57.15 56.2,57.15 55.88,56.83 55.29,56.83 C308.2
  Top 0.406: C308.2 54.93,54.4 R304.1
N$35
  Top 0.254: IC102.18 86.08,43.78 85.72,44.13 77.15,44.13 71.12,38.1 R110.1
  Top 0.305: IC102.18 86.08,35.2 87,34.29 100.97,34.29 101.6,33.66 101.6,24.77 105.41,20.95 J103.P$1
N$36
  Top 0.254: IC102.16 84.78,42.54 84.45,42.86 79.06,42.86 74.93,38.73 R108.1
  Top 0.305: IC102.16 84.78,33.97 85.72,33.02 99.69,33.02 100.33,32.38 J103.P$5
N$37
  Top 0.254: IC102.17 85.43,43.16 85.09,43.5 78.42,43.5 73.03,38.1 R109.1
  Top 0.305: IC102.17 85.43,34.59 86.36,33.66 100.33,33.66 100.97,33.02 100.97,24.13 102.87,22.23 J103.P$3
N$38  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.12 77.08,57.47 v78.42,57.47 | v61.59,71.75 J101.3
  Bottom 0.254: v61.59,71.75 60.64,71.75 60.33,72.07 60.33,74.93 60.64,75.25 64.14,75.25 78.42,60.96 v78.42,57.47
N$39
  Top 0.254: IC102.15 84.13,41.92 83.82,42.23 79.69,42.23 76.83,39.37 R113.1
  Top 0.305: IC102.15 84.13,33.97 83.19,33.02 60.33,33.02 59.69,32.38 J102.P$1
N$40
  Top 0.254: IC102.14 83.48,41.3 83.19,41.59 80.33,41.59 78.74,40.01 R112.1
  Top 0.305: IC102.14 83.48,34.59 82.55,33.66 60.01,33.66 59.05,32.7 59.05,23.18 57.15,21.27 J102.P$3
N$41
  Top 0.305: 82.83,37.13 82.83,35.2 81.92,34.29 59.69,34.29 58.42,33.02 58.42,24.13 54.61,20.32 J102.P$5 | 82.83,37.13 IC102.13 | R111.1 82.74,37.05 82.83,37.13
N$42
  Top 0.61: IC231.7 128.91,39.37 129.54,40.01 129.54,41.17 R231.1
N$43  (via drill 0.41 pad 0.81)
  Top 0.61: v121.28,36.83 IC231.4 | v121.28,24.77 R232.1
  Bottom 0.61: v121.28,24.77 v121.28,36.83
N$44  (via drill 0.41 pad 0.81)
  Top 0.61: v121.28,65.41 IC241.4 | v121.28,53.34 R242.1
  Bottom 0.61: v121.28,53.34 v121.28,65.41
N$45
  Top 0.61: IC241.7 128.91,67.94 129.54,68.58 129.54,69.75 R241.1
N$46  (via drill 0.41 pad 0.81)
  Top 0.61: v121.28,93.98 IC251.4 | v121.28,81.92 R252.1
  Bottom 0.61: v121.28,81.92 v121.28,93.98
N$47
  Top 0.61: IC251.7 128.91,96.52 129.54,97.16 129.54,98.32 R251.1
N$48
  Top 0.61: IC231.8 127.41,40.64 C232.2 127.81,41.05 D231.C
N$49
  Top 0.61: IC241.8 127.41,69.22 C242.2 127.81,69.62 D5.C
N$50
  Top 0.61: C252.2 127.41,97.79 IC251.8 124.46,97.85 124.46,98.42 123.83,99.06 116.84,99.06 116.39,98.61 D6.C
N$51
  Top 0.61: T201.G 28.68,17.14 R201.2
N$52
  Top 0.61: T202.G R202.2
N$53
  Top 0.61: R211.2 28.68,45.62 28.57,45.72 T211.G
N$54
  Top 0.61: T212.G R212.2
N$55
  Top 0.61: R221.2 28.68,74.19 28.57,74.3 T221.G
N$56
  Top 0.61: T222.G R222.2
N$57
  Top 0.61: R232.2 T8.G
N$58
  Top 0.61: R231.2 131.34,39.47 131.44,39.37 T231.G
N$59
  Top 0.61: R241.2 131.34,68.05 131.44,67.94 T241.G
N$60
  Top 0.61: R242.2 T242.G
N$61
  Top 0.61: R251.2 131.34,96.62 131.44,96.52 T251.G
N$62
  Top 0.61: R252.2 T252.G
N$63  (via drill 0.41 pad 0.81)
  Top 0.254: v46.99,33.66 46.99,31.97 LED101.A
  Top 0.305: v80.33,76.83 R101.1
  Bottom 0.254: v46.99,33.66 46.99,39.37
  Bottom 0.305: v80.33,76.83 79.69,77.47 55.88,77.47 55.24,76.83 55.24,62.23 52.39,59.37 52.39,49.21 51.44,48.26 50.16,48.26 49.21,47.31 49.21,41.91 46.99,39.69 46.99,39.37
N$64
  Top 0.254: IC108.3 68.88,84.47 68.58,84.77 J100.P$11
N$65
  Top 0.254: IC106.3 63.8,84.47 63.5,84.77 J100.P$7
N$66
  Top 0.254: IC105.3 61.26,84.47 60.96,84.77 J100.P$5
N$67
  Top 0.254: IC104.3 58.72,84.47 58.42,84.77 J100.P$3
N$68
  Top 0.254: IC103.3 56.18,84.15 55.88,84.45 J100.P$1
N$69  (via drill 0.41 pad 0.81)
  Top 0.254: IC233.3 102.23,63.28 v102.23,61.59
  Top 0.305: IC232.1 113,39.66 v113.03,39.69 | v102.23,61.59 C233.2
  Bottom 0.305: v113.03,39.69 102.23,50.48 v102.23,61.59
N$70  (via drill 0.41 pad 0.81)
  Top 0.305: v82.55,76.83 R102.1 | LED102.A 46.77,61.81 v46.67,61.91
  Bottom 0.305: v82.55,76.83 82.55,77.47 81.92,78.11 55.24,78.11 54.61,77.47 54.61,62.87 53.66,61.91 v46.67,61.91
N$71  (via drill 0.41 pad 0.81)
  Top 0.305: v84.77,76.83 R103.1 | v48.9,88.9 LED103.A
  Bottom 0.305: v84.77,76.83 84.77,78.11 84.14,78.74 57.15,78.74 55.88,80.01 55.88,84.45 54.61,85.72 50.16,85.72 48.9,87 v48.9,88.9
N$72  (via drill 0.41 pad 0.81)
  Top 0.305: R104.1 v87,76.83 | v113.35,80.96 113.35,82.45 LED104.A
  Bottom 0.305: v87,76.83 87,78.11 87.63,78.74 104.78,78.74 106.05,77.47 112.08,77.47 113.35,78.74 v113.35,80.96
N$73  (via drill 0.41 pad 0.81)
  Top 0.305: R105.1 v89.22,76.83 | v113.03,51.44 113.03,53.12 LED105.A
  Bottom 0.305: v89.22,76.83 89.22,77.79 89.53,78.11 104.14,78.11 109.22,73.03 109.22,55.24 v113.03,51.44
N$74  (via drill 0.41 pad 0.81)
  Top 0.305: v91.44,76.83 R106.1 | v113.03,22.86 113.03,24.55 LED106.A
  Bottom 0.305: v91.44,76.83 104.14,76.83 108.58,72.39 108.58,54.61 109.86,53.34 109.86,46.35 114.3,41.91 114.3,37.47 111.76,34.92 111.76,24.13 v113.03,22.86
N$75
  Top 0.254: 47.12,75.14 IC222.1 49.53,75.25 50.48,74.3 50.48,53.34 51.44,52.39 54.85,52.39 C223.2 56.45,50.78 IC2.3
N$76  (via drill 0.41 pad 0.81)
  Top 0.254: IC203.3 56.45,45.7 C203.2
  Top 0.305: IC202.1 v48.58,18.1 | v51.12,46.99 55.17,46.99 C203.2
  Bottom 0.305: v48.58,18.1 49.53,19.05 49.53,33.02 47.62,34.92 47.62,39.37 50.16,41.91 50.16,46.04 v51.12,46.99
N$77  (via drill 0.41 pad 0.81)
  Top 0.254: C243.2 104.79,61.2 IC243.3
  Top 0.305: v111.13,66.99 IC242.1 | v111.12,70.48 109.22,70.48 108.58,69.85 108.58,55.56 107.95,54.93 105.41,54.93 104.78,55.56 v104.78,56.52 | v104.78,61.59 C243.2
  Bottom 0.305: v111.13,66.99 v111.13,70.48 v111.12,70.48 | v104.78,56.52 v104.78,61.59
N$78
  Top 0.305: IC305.5 77.8,21.9 78.74,20.95 79.38,20.95 80.01,20.32 J303.3
N$80  (via drill 0.41 pad 0.81)
  Top 0.254: IC213.3 56.45,48.24 C213.2
  Top 0.305: IC212.1 47.02,45.12 v46.99,45.09 | v51.12,49.53 55.17,49.53 C213.2
  Bottom 0.305: v46.99,45.09 46.99,48.9 47.62,49.53 v51.12,49.53
N$81
  Top 0.254: IC253.3 107.31,63.28 C253.2
  Top 0.305: IC252.1 109.54,87.95 106.68,85.09 105.41,85.09 104.14,83.82 104.14,79.38 107.95,75.56 107.95,63.5 107.73,63.28 IC253.3
PDI
  Top 0.254: IC101.89 72.39,66.6 72.39,86.36 71.12,87.63 J100.P$13
PF0
  Top 0.254: IC101.45 90.04,54.61 95.25,54.61 97.16,56.52 97.16,81.28 104.14,88.27 J100.P$39
PF1
  Top 0.254: IC101.46 90.11,55.24 94.61,55.24 96.52,57.15 96.52,81.92 101.6,87 J100.P$37
PF2
  Top 0.254: IC101.47 90.17,55.89 90.17,55.88 93.98,55.88 95.89,57.78 95.89,82.55 99.06,85.72 J100.P$35
PF3
  Top 0.254: IC101.48 90.26,56.52 93.34,56.52 95.25,58.42 95.25,83.19 96.52,84.45 J100.P$33
PF4
  Top 0.254: IC101.49 90.33,57.15 92.71,57.15 94.61,59.05 94.61,83.19 93.98,83.82 J100.P$31
PF5
  Top 0.254: IC101.50 90.4,57.78 92.08,57.78 93.98,59.69 93.98,82.55 91.44,85.09 J100.P$29
PF6
  Top 0.254: IC101.51 93.34,64.54 93.34,81.92 88.9,86.36 J100.P$27
PF7
  Top 0.254: IC101.52 92.71,64.61 92.71,81.28 86.36,87.63 J100.P$25
PK0
  Top 0.254: IC101.75 78.74,71.92 78.74,82.55 83.82,87.63 J100.P$23
PK1
  Top 0.254: IC101.76 78.11,70.08 78.11,83.19 82.55,87.63 82.55,91.44 83.82,92.71 J100.P$24
PK2
  Top 0.254: IC101.77 77.47,70.01 77.47,83.82 81.28,87.63 J100.P$21
PK3
  Top 0.254: IC101.78 76.83,69.94 76.83,84.45 80.01,87.63 80.01,91.44 81.28,92.71 J100.P$22
PK4
  Top 0.254: IC101.79 76.2,69.86 76.2,85.09 78.74,87.63 J100.P$19
PK5
  Top 0.254: IC101.80 75.56,69.79 75.56,85.72 77.47,87.63 77.47,91.44 78.74,92.71 J100.P$20
PK6
  Top 0.254: IC101.81 74.93,69.72 74.93,86.36 76.2,87.63 J100.P$17
PK7
  Top 0.254: J100.P$18 76.2,92.71 74.93,91.44 74.93,87.63 74.3,87 74.3,69.65 IC101.82
PQ2
  Top 0.254: IC101.87 73.66,66.75 J100.P$15
PQ3
  Top 0.254: J100.P$16 73.66,92.71 72.39,91.44 72.39,87.63 73.03,87 73.03,66.67 IC101.88
PWR_INT  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.22 75.88,49.2 v75.88,47.62
  Top 0.305: J303.5 v77.47,20.64 | R308.1 75.88,46.14 v75.88,47.62
  Bottom 0.305: v75.88,47.62 77.47,46.04 v77.47,20.64
PWR_SCL  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.26 81.92,49.3 v81.92,47.62
  Top 0.305: v79.38,28.89 78.42,27.94 78.42,27.08 IC305.3
  Bottom 0.305: v79.38,28.89 79.38,45.09 v81.92,47.62
PWR_SDA  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.25 77.47,48.66 v77.47,47.62
  Top 0.305: v78.42,29.84 78.42,28.89 77.79,28.26 77.79,27.06 IC305.4
  Bottom 0.305: v77.47,47.62 78.42,46.67 v78.42,29.84
RESET  (via drill 0.41 pad 0.81)
  Top 0.254: 70.48,92.08 69.85,91.44 69.85,87.63 71.75,85.72 71.75,76.2 | 70.48,92.08 71.12,92.71 J100.P$14 | IC101.90 71.75,66.53 71.75,76.2 | v70.48,76.2 71.75,76.2 | R107.1 49.11,92.08 70.48,92.08
  Top 0.305: J101.6 v56.52,67.94 | R107.1 C111.2
  Bottom 0.305: v56.52,67.94 56.52,75.25 57.47,76.2 v70.48,76.2
U1  (via drill 0.61 pad 0.81)
  Top 0.305: 32.38,22.23 32.38,21.59 | 32.38,22.23 R204.P$1 | 32.38,22.23 34.92,22.23 35.56,21.59 41.91,21.59 43.5,20 IC202.4
  Top 0.61: IC201.6 32.62,18.41 C202.1
  other vias: 22.86,39.37 20.95,39.37 19.05,39.37 17.14,39.37 15.24,39.37 13.34,39.37 13.34,37.47 13.34,35.56 13.34,33.66 13.34,31.75 15.24,37.47 17.14,37.47 19.05,37.47 15.24,35.56 15.24,33.66 15.24,31.75 17.14,31.75 19.05,31.75 20.95,31.75 22.86,31.75 22.86,33.66 22.86,37.47 22.86,35.56 20.95,37.47 19.05,35.56 17.14,35.56 17.14,33.66 19.05,33.66 20.95,35.56 20.95,33.66
  pour Top (no thermals): 33.02,18.41 25.4,18.41 25.4,26.67 24.13,27.94 12.06,27.94 12.06,42.55 23.5,42.55 23.5,31.11 24.13,30.48 33.02,30.48
  pour Bottom (isolate 0.61, no thermals): 26.67,42.23 0,42.23 0,15.56 9.53,15.56 9.53,28.89 26.67,28.89
U1H
  Top 0.254: IC201.1 50.16,15.88 50.8,16.51 50.8,18.41 57.15,24.77 57.15,41.27 57.78,41.91 67.18,41.91 IC101.20
U1L
  Top 0.254: IC201.2 42.23,17.14 42.86,16.51 49.53,16.51 50.16,17.14 50.16,18.73 56.52,25.08 56.52,41.91 57.15,42.55 67.11,42.55 IC101.19
U1O
  Top 0.305: IC202.5 44.42,18.7 44.77,19.05 45.4,19.05 45.72,19.37 45.72,23.18 J_U1.P$4
  pour Top (no thermals): 36.83,30.48 36.83,22.23 47.62,22.23 47.62,30.48
U2  (via drill 0.61 pad 0.81)
  Top 0.305: IC232.4 116.52,36.52 118.11,34.92 124.46,34.92 125.41,33.97 126.68,33.97 R233.P$1 | C232.1 127.64,35.56
  Top 0.61: IC231.6 127.41,38.1 C232.1
  other vias: 137.16,17.14 139.06,17.14 140.97,17.14 142.88,17.14 144.78,17.14 146.69,17.14 146.69,19.05 146.69,20.95 146.69,22.86 146.69,24.77 144.78,19.05 142.88,19.05 140.97,19.05 144.78,20.95 144.78,22.86 144.78,24.77 142.88,24.77 140.97,24.77 139.06,24.77 137.16,24.77 137.16,22.86 137.16,19.05 137.16,20.95 139.06,19.05 140.97,20.95 142.88,20.95 142.88,22.86 140.97,22.86 139.06,20.95 139.06,22.86
  pour Top (no thermals): 127,38.1 134.62,38.1 134.62,29.84 135.89,28.57 147.96,28.57 147.96,15.88 147.32,15.24 136.53,15.24 136.53,25.4 135.89,26.04 127,26.04
  pour Bottom (isolate 0.61, no thermals): 120.02,0.32 160.02,0.32 160.02,27.62 133.35,27.62 133.35,19.05 120.02,5.71
U2H
  Top 0.254: IC101.36 88.44,49.85 112.39,49.85 113.35,48.9 113.35,42.23 114.94,40.64 IC231.1
U2L
  Top 0.254: IC101.35 88.37,49.21 112.08,49.21 112.71,48.58 112.71,41.91 114.62,40.01 117.16,40.01 117.79,39.37 IC231.2
U2O
  Top 0.305: J_U2.P$4 114.3,33.34 114.3,36.83 114.94,37.47 115.25,37.47 115.6,37.81 IC232.5
  pour Top (no thermals): 123.19,26.04 112.39,26.04 112.39,34.29 123.19,34.29
V1  (via drill 0.61 pad 0.81)
  Top 0.305: IC212.4 43.5,48.58 41.91,50.16 35.56,50.16 34.92,50.8 32.38,50.8 R213.P$1 | C212.1 32.38,50.16
  Top 0.61: IC211.6 32.62,46.99 C212.1
  other vias: 22.86,67.94 20.95,67.94 19.05,67.94 17.14,67.94 15.24,67.94 13.34,67.94 13.34,66.04 13.34,64.14 13.34,62.23 13.34,60.33 15.24,66.04 17.14,66.04 19.05,66.04 15.24,64.14 15.24,62.23 15.24,60.33 17.14,60.33 19.05,60.33 20.95,60.33 22.86,60.33 22.86,62.23 22.86,66.04 22.86,64.14 20.95,66.04 19.05,64.14 17.14,64.14 17.14,62.23 19.05,62.23 20.95,64.14 20.95,62.23
  pour Top (no thermals): 33.02,46.99 25.4,46.99 25.4,55.24 24.13,56.52 12.06,56.52 12.06,71.12 23.5,71.12 23.5,59.69 24.13,59.05 33.02,59.05
  pour Bottom (isolate 0.61, no thermals): 26.67,70.17 0,70.17 0,57.47 26.67,57.47
V1H
  Top 0.254: IC211.1 42.55,44.45 43.81,43.18 67.03,43.18 IC101.18
V1L
  Top 0.254: IC211.2 42.23,45.72 44.13,43.81 66.96,43.81 IC101.17
V1O
  Top 0.305: J_V1.P$2 45.72,51.75 45.72,48.26 45.09,47.62 44.77,47.62 44.42,47.28 IC212.5
  pour Top (no thermals): 36.83,59.05 36.83,50.8 47.62,50.8 47.62,59.05
V2  (via drill 0.61 pad 0.81)
  Top 0.305: IC242.4 116.52,65.09 118.11,63.5 124.78,63.5 125.73,62.55 127.32,62.55 127.32,61.28 R244.P$1
  Top 0.61: IC241.6 127.41,66.67 C242.1
  other vias: 137.16,45.72 139.06,45.72 140.97,45.72 142.88,45.72 144.78,45.72 146.69,45.72 146.69,47.62 146.69,49.53 146.69,51.44 146.69,53.34 144.78,47.62 142.88,47.62 140.97,47.62 144.78,49.53 144.78,51.44 144.78,53.34 142.88,53.34 140.97,53.34 139.06,53.34 137.16,53.34 137.16,51.44 137.16,47.62 137.16,49.53 139.06,47.62 140.97,49.53 142.88,49.53 142.88,51.44 140.97,51.44 139.06,49.53 139.06,51.44
  pour Top (no thermals): 127,66.67 134.62,66.67 134.62,58.42 135.89,57.15 147.96,57.15 147.96,42.55 136.53,42.55 136.53,53.98 135.89,54.61 127,54.61
  pour Bottom (isolate 0.61, no thermals): 133.35,43.18 160.02,43.18 160.02,56.2 133.35,56.2
V2H
  Top 0.254: IC101.38 88.58,51.12 108.58,51.12 109.22,51.75 109.22,68.26 110.17,69.22 IC241.1
V2L
  Top 0.254: IC101.37 88.51,50.48 109.22,50.48 109.86,51.12 109.86,67.94 110.49,68.58 117.16,68.58 117.79,67.94 IC241.2
V2O
  Top 0.305: J_V2.P$4 114.3,61.91 114.3,65.41 114.94,66.04 115.25,66.04 115.57,66.36 115.57,66.99 IC242.5
  pour Top (no thermals): 123.19,54.61 112.39,54.61 112.39,62.87 123.19,62.87
VCC  (via drill 0.41 pad 0.81)
  Top 0.254: v78.11,54.61 75.64,54.61 IC101.14 70.88,49.85 v69.22,49.85 | v80.64,52.7 80.64,52.55 | IC101.44 87,56.95 v87,58.42 | IC101.54 87.64,60.96 v86.36,60.96 | IC101.34 83.19,53.69 83.19,54.61 v83.82,55.24 82.87,56.2 | IC101.74 79.85,67.31 v79.38,67.31 | IC101.83 77.19,66.04 v78.74,66.04 | IC101.64 84.38,64.77 v82.55,64.77 | C307.+ 67.06,36.85 | IC103.5 57.48,81.93 58.1,82.55 58.1,84.14 57.78,84.45 57.78,85.41 v56.83,86.36 | IC104.5 60.02,81.93 60.64,82.55 60.64,84.14 60.33,84.45 60.33,85.41 v59.37,86.36 | IC105.5 62.56,81.93 63.18,82.55 63.18,84.14 62.87,84.45 62.87,85.41 v61.91,86.36 | IC106.5 65.1,81.93 65.72,82.55 65.72,84.14 65.41,84.45 65.41,85.41 v64.45,86.36 | IC107.5 67.64,81.93 68.26,82.55 68.26,84.14 67.94,84.45 67.94,85.41 v66.99,86.36 | IC108.5 70.18,81.93 70.8,82.55 70.8,85.09 v69.53,86.36 | IC203.5 60.66,47.01 v60.96,47.31 | v60.96,49.85 60.64,49.53 59.92,49.53 IC213.5 | v60.96,52.39 60.96,52.07 59.92,52.07 IC2.5 | IC233.5 100.97,65 v100.97,67.31 103.5,67.31 | 103.5,67.31 103.49,67.3 IC243.5 | IC253.5 106.05,65 106.05,67.31 103.5,67.31 | IC101.24 79.92,51.82 79.92,51.98
  Top 0.305: R107.2 50.38,90.59 50.8,90.17 v50.8,87 48.26,84.45 v48.26,77.15 | R307.2 107.73,32.17 107.95,32.38 111.12,32.38 111.76,33.02 111.76,36.2 112.08,36.51 | IC102.2 86.73,44.81 86.69,44.77 | IC102.10 81.53,44.81 81.48,44.77 | R308.2 77.79,45.94 77.79,44.77 | IC305.2 79.09,26.07 78.74,25.72 76.52,25.72 v75.56,26.67 | v74.93,44.45 | 75.72,43.66 v74.93,44.45
  Top 0.406: IC202.3 47.94,20 v48.58,20 48.58,32.38 | IC212.3 v48.26,48.58 v48.26,69.22 | IC222.3 48.58,77.15 v48.26,77.15 | v111.44,89.22 IC252.3 | v111.44,89.22 | v51.44,70.48 J101.4 | 80.64,54.61 v78.11,54.61 | 80.64,54.61 v80.64,52.7 79.92,51.98 79.92,44.85 80.01,44.77 | 86.04,59.37 v87,58.42 | 86.04,59.37 85.41,60.01 | 85.41,60.01 v86.36,60.96 | 85.41,60.01 81.6,63.82 | 81.6,63.82 79.38,66.04 | 79.38,66.04 v78.74,66.04 | 79.38,66.04 v79.38,67.31 | 81.6,63.82 v82.55,64.77 | 86.04,59.37 82.87,56.2 81.28,54.61 80.64,54.61 | 62.55,36.51 66.59,36.51 C307.+ 67.4,36.51 68.58,36.51 75.72,43.66 76.83,44.77 77.79,44.77 80.01,44.77 | IC242.3 v111.13,65.09 v111.12,65.09 v111.12,51.44 | IC232.3 112.08,36.51 111.76,36.83 111.76,46.35 v111.12,46.99 v100.97,46.99 90.17,46.99 87.95,44.77 86.69,44.77 81.48,44.77 80.01,44.77 | v111.44,89.22 111.44,83.5 111.76,83.19 v111.76,71.75 | 48.58,32.38 48.58,33.97 47.62,34.92 v47.62,41.91 | 48.58,32.38 v55.56,32.38 | v58.1,34.92 60.96,34.92 62.55,36.51 | 62.55,36.51 62.55,37.44 IC303.5
  Top 0.61: J100.P$38 101.6,92.71 v102.87,92.71 104.14,92.71 J100.P$40
  Bottom 0.254: 80.64,50.53 C105.2 | 76.91,53.41 C108.2 | v83.82,55.24 83.96,55.24 | 87.56,57.86 C102.2 | 83.89,66.11 C104.2 | v50.8,87 56.2,87 v56.83,86.36 v59.37,86.36 v61.91,86.36 v64.45,86.36 v66.99,86.36 v69.53,86.36 | v60.96,49.85 v60.96,47.31 | v60.96,49.85 v60.96,52.39 | v69.22,49.85 v60.96,49.85
  Bottom 0.305: v100.97,46.99 v100.97,67.31 | v75.56,26.67 76.52,27.62 76.52,42.86 v74.93,44.45
  Bottom 0.406: v48.26,69.22 48.26,70.48 | 48.26,70.48 v48.26,77.15 | v111.44,89.22 111.44,92.08 110.81,92.71 v102.87,92.71 | v78.11,54.61 76.91,53.41 | 83.96,55.24 C106.2 | v87,58.42 87.56,57.86 | v86.36,60.96 86.63,60.69 C103.2 | v79.38,67.31 79.01,67.67 C101.2 | C107.2 78.25,66.04 v78.74,66.04 | v82.55,64.77 83.89,66.11 | C105.2 80.96,50.12 | v80.64,52.7 80.64,50.53 | v111.12,46.99 v111.12,51.44 | v48.26,48.58 48.26,42.55 v47.62,41.91 | 48.26,70.48 v51.44,70.48 | v111.12,65.09 113.03,66.99 113.03,70.48 v111.76,71.75 | v55.56,32.38 v58.1,34.92
VS  (via drill 0.61 pad 0.81)
  Top 0.203: J301.P$4 69.85,6.35 70.48,5.71
  Top 0.305: v17.14,49.53 T211.D | v17.14,20.95 T201.D | T221.D v19.05,78.11
  Top 0.406: T241.D v142.88,64.14 | v142.88,35.56 T231.D
  Top 0.61: 67.94,18.41 67.31,17.78 J301.P$6
  Top 1.016: 153.67,35.56 153.99,35.56 154.31,35.24 | v146.69,67.94 152.4,67.94 154.31,66.04 | 5.71,53.34 v13.34,53.34 | 5.71,78.11 6.35,78.11 | 6.35,20.95 6.35,20.32 5.71,19.68
  Top 10.16: 18.41,5.71 70.48,5.71 143.51,5.71 | v17.14,49.53 T211.D | 5.71,18.41 5.71,19.68 5.71,53.34 5.71,78.11 | 154.31,16.51 154.31,35.24 154.31,66.04 154.31,78.11 | v17.14,20.95 T201.D | v142.88,35.56 T231.D | T241.D v142.88,64.14
  Top 11.176: 6.35,20.95 v17.14,20.95 | 6.35,78.11 T221.D | 6.67,49.53 v17.14,49.53 | 153.67,35.56 v142.88,35.56 | v142.88,64.14 153.35,64.14
  other vias: 22.86,81.92 20.95,81.92 19.05,81.92 17.14,81.92 15.24,81.92 13.34,81.92 13.34,80.01 13.34,78.11 13.34,76.2 13.34,74.3 15.24,80.01 17.14,80.01 19.05,80.01 15.24,78.11 15.24,76.2 15.24,74.3 17.14,74.3 19.05,74.3 20.95,74.3 22.86,74.3 22.86,76.2 22.86,80.01 22.86,78.11 20.95,80.01 17.14,78.11 17.14,76.2 19.05,76.2 20.95,78.11 20.95,76.2 22.86,53.34 20.95,53.34 19.05,53.34 17.14,53.34 15.24,53.34 13.34,51.44 13.34,49.53 13.34,47.62 13.34,45.72 15.24,51.44 17.14,51.44 19.05,51.44 15.24,49.53 15.24,47.62 15.24,45.72 17.14,45.72 19.05,45.72 20.95,45.72 22.86,45.72 22.86,47.62 22.86,51.44 22.86,49.53 20.95,51.44 19.05,49.53 17.14,47.62 19.05,47.62 20.95,49.53 20.95,47.62 22.86,24.77 20.95,24.77 19.05,24.77 17.14,24.77 15.24,24.77 13.34,24.77 13.34,22.86 13.34,20.95 13.34,19.05 13.34,17.14 15.24,22.86 17.14,22.86 19.05,22.86 15.24,20.95 15.24,19.05 15.24,17.14 17.14,17.14 19.05,17.14 20.95,17.14 22.86,17.14 22.86,19.05 22.86,22.86 22.86,20.95 20.95,22.86 19.05,20.95 17.14,19.05 19.05,19.05 20.95,20.95 20.95,19.05 137.16,31.75 139.06,31.75 140.97,31.75 142.88,31.75 144.78,31.75 146.69,31.75 146.69,33.66 146.69,35.56 146.69,37.47 146.69,39.37 144.78,33.66 142.88,33.66 140.97,33.66 144.78,35.56 144.78,37.47 144.78,39.37 142.88,39.37 140.97,39.37 139.06,39.37 137.16,39.37 137.16,37.47 137.16,33.66 137.16,35.56 139.06,33.66 140.97,35.56 142.88,37.47 140.97,37.47 139.06,35.56 139.06,37.47 137.16,60.33 139.06,60.33 140.97,60.33 142.88,60.33 144.78,60.33 146.69,60.33 146.69,62.23 146.69,64.14 146.69,66.04 144.78,62.23 142.88,62.23 140.97,62.23 144.78,64.14 144.78,66.04 144.78,67.94 142.88,67.94 140.97,67.94 139.06,67.94 137.16,67.94 137.16,66.04 137.16,62.23 137.16,64.14 139.06,62.23 140.97,64.14 142.88,66.04 140.97,66.04 139.06,64.14 139.06,66.04 137.16,88.9 139.06,88.9 140.97,88.9 142.88,88.9 144.78,88.9 146.69,88.9 146.69,90.81 146.69,92.71 146.69,94.61 146.69,96.52 144.78,90.81 142.88,90.81 140.97,90.81 144.78,92.71 144.78,94.61 144.78,96.52 142.88,96.52 140.97,96.52 139.06,96.52 137.16,96.52 137.16,94.61 137.16,90.81 137.16,92.71 139.06,90.81 140.97,92.71 142.88,92.71 142.88,94.61 140.97,94.61 139.06,92.71 139.06,94.61
  pour Top (no thermals): 64.14,19.68 64.14,12.7 62.23,10.79 62.23,1.27 74.93,1.27 74.93,10.79 73.03,12.7 73.03,19.68
  pour Top (isolate 0.61): 132.08,1.27 158.75,1.27 158.75,19.68 149.86,19.68 149.86,15.24 147.96,13.34 136.53,13.34 132.08,8.89
  pour Top (isolate 0.61, no thermals): 27.94,1.27 1.27,1.27 1.27,19.68 10.16,19.68 10.16,16.19 11.11,15.24 23.18,15.24 29.53,8.89
  pour Top (isolate 0.61, no thermals): 149.86,74.3 149.86,83.82 146.05,87.63 136.84,87.63 136.84,98.42 158.75,98.42 158.75,74.3
  pour Bottom (isolate 0.61, no thermals): 26.67,84.77 0,84.77 0,71.44 26.67,71.44
  pour Bottom (isolate 0.61, no thermals): 26.67,56.2 0,56.2 0,43.5 26.67,43.5
  pour Bottom (isolate 0.61, no thermals): 26.04,27.62 10.79,27.62 10.79,14.29 0,14.29 0,-0.32 39.37,-0.32 39.37,1.91 26.04,15.24
  pour Bottom (isolate 0.61, no thermals): 133.35,28.89 160.02,28.89 160.02,41.91 133.35,41.91
  pour Bottom (isolate 0.61, no thermals): 133.35,57.47 160.02,57.47 160.02,70.48 133.35,70.48
  pour Bottom (isolate 0.61, no thermals): 133.35,86.04 160.02,86.04 160.02,99.38 133.35,99.38
W1  (via drill 0.61 pad 0.81)
  Top 0.305: IC222.4 43.5,77.15 41.91,78.74 35.56,78.74 34.92,79.38 32.38,79.38 | 32.38,78.11 32.38,79.38 | 32.38,79.38 R224.P$1
  Top 0.61: IC221.6 32.62,75.56 C222.1
  other vias: 22.86,96.52 22.86,94.61 22.86,92.71 22.86,90.81 22.86,88.9 20.95,88.9 19.05,88.9 17.14,88.9 15.24,88.9 13.34,88.9 13.34,90.81 13.34,92.71 15.24,90.81 17.14,90.81 19.05,90.81 20.95,90.81 20.95,92.71 19.05,92.71 17.14,92.71 15.24,92.71 20.95,94.61 19.05,94.61 17.14,94.61 15.24,94.61 13.34,94.61 20.95,96.52 19.05,96.52 17.14,96.52 15.24,96.52 13.34,96.52
  pour Top (no thermals): 33.02,75.56 25.4,75.56 25.4,83.82 24.13,85.09 12.06,85.09 12.06,98.42 23.5,98.42 23.5,88.27 24.13,87.63 33.02,87.63
  pour Top (isolate 0.61, no thermals): 13.34,85.27 0.64,85.27 0.64,98.25 13.34,98.25
  pour Bottom (isolate 0.61, no thermals): 26.67,86.04 0,86.04 0,99.69 26.67,99.69
W1H
  Top 0.254: IC101.16 66.89,44.45 50.48,44.45 49.21,45.72 49.21,69.85 47.94,71.12 44.45,71.12 42.55,73.03 IC221.1
W1L
  Top 0.254: IC221.2 42.23,74.3 44.77,71.75 48.58,71.75 49.85,70.48 49.85,46.35 51.12,45.09 66.82,45.09 IC101.15
W1O
  Top 0.305: J_W1.P$2 46.04,80.64 45.72,80.64 45.72,76.83 45.09,76.2 44.77,76.2 44.42,75.85 IC222.5
  pour Top (no thermals): 36.83,87.63 36.83,79.38 47.62,79.38 47.62,87.63
W2  (via drill 0.61 pad 0.81)
  Top 0.406: C252.1 127.64,92.71 113.67,92.71 113.03,93.34 112.39,93.34 111.76,93.98 111.47,93.98 IC252.4 111.73,94.01
  Top 0.61: IC251.6 127.41,95.25 C252.1
  other vias: 137.16,74.3 139.06,74.3 140.97,74.3 142.88,74.3 144.78,74.3 146.69,74.3 146.69,76.2 146.69,78.11 146.69,80.01 146.69,81.92 144.78,76.2 142.88,76.2 140.97,76.2 144.78,78.11 144.78,80.01 144.78,81.92 142.88,81.92 140.97,81.92 139.06,81.92 137.16,81.92 137.16,80.01 137.16,76.2 137.16,78.11 139.06,76.2 140.97,78.11 142.88,78.11 142.88,80.01 140.97,80.01 139.06,78.11 139.06,80.01
  pour Top (no thermals): 127,95.25 134.62,95.25 134.62,87 135.89,85.72 145.41,85.72 147.96,83.19 147.96,71.12 136.53,71.12 136.53,82.55 135.89,83.19 127,83.19
  pour Bottom (isolate 0.61, no thermals): 133.35,71.75 160.02,71.75 160.02,84.77 133.35,84.77
W2H  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.40 88.73,52.39 93.98,52.39 97.79,56.2 97.79,80.64 103.5,86.36 106.05,86.36 107.31,87.63 v107.31,96.52
  Top 0.305: v121.28,97.47 120.97,97.79 IC251.1
  Bottom 0.406: v121.28,97.47 118.11,97.47 116.84,96.52 110.49,96.52 109.22,97.79 107.95,97.79 107.31,97.16 v107.31,96.52
W2L  (via drill 0.41 pad 0.81)
  Top 0.254: IC101.39 88.65,51.75 94.3,51.75 98.42,55.88 98.42,80.01 104.14,85.72 106.36,85.72 108.58,87.95 v108.58,96.52
  Top 0.406: IC251.2 120.65,96.52 v121.28,95.89
  Bottom 0.406: v121.28,95.89 109.22,95.89 v108.58,96.52
W2O
  Top 0.406: IC252.5 109.54,93.66 110.49,92.71 112.39,92.71 113.67,91.44 J_W2.P$4
  pour Top (no thermals): 123.19,83.82 112.39,83.82 112.39,92.08 123.19,92.08

## Text on the board
Top: ScootyPuff Control | by Ernst Abrazzo | Summer 2009 | REV. 1.2